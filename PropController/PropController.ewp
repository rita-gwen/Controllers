# IAR project PropController.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; DEBUG
  ICCARM.CCIncludePath2: .\; Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; App
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: PropController.sim
  ILINK.IlinkOutputFile: taskSync.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  group App
    App/: controller.c controller.h main.c tasks.c util.c
  group App/uCOS
    App/uCOS/: app_cfg.h app_hooks.c os_cfg.h
  group BSP
    BSP/: adc.c adc.h bsp.c bsp.h datainit.c hw_init.c hw_init.h layout.icf nucleoboard.h startup.s tim.c tim.h uart.c uart.h
  group BSP/CMSIS
    BSP/CMSIS/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f4xx.h
  group BSP/ST/StdPeripheralDrivers
    BSP/ST/StdPeripheralDrivers/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_conf.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h
  group Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR
    Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Micrium/Software/uCOS-II/Source
    Micrium/Software/uCOS-II/Source/: os_cfg_r.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c ucos_ii.h
  group Util
    Util/: print.c print.h
